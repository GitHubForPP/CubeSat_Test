# Keil uVision project bd_slave_board.uvprojx, settings and files
target bd_slave_target (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: space +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\User;..\Core;..\Alientek\SYSTEM\sys;..\Alientek\SYSTEM\usart;..\Contiki\cpu;..\STM32F10x_FWLib\inc;..\Hardware\Ymodem;..\Hardware\orbit
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c
  group Core
    ../Core/: core_cm3.c startup_stm32f10x_hd.s
  group Alientek_system
    ../Alientek/SYSTEM/sys/: sys.c
    ../Alientek/SYSTEM/usart/: usart.c
  group Hardware
    ../Hardware/Ymodem/: ymodem.c
    ../Hardware/orbit/: tle.c TimeSpan.c DataTime.c util.c Vector.c eci.c OrbitalElements.c SGP4.c
  group STM32F10x_FWLib_3_5
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
