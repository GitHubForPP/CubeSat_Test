# Keil uVision project CubeSat_Boot.uvprojx, settings and files
target Boot (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CubeSat_Boot
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ./bin/CubeSat_Boot.bin ./Objects/CubeSat_Boot.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User;..\Bsp\led;..\Bsp\systick;..\Bsp\spi_flash;..\Bsp\internal_flash;..\Bsp\sdram;..\Bsp\uart;..\Moudle\Mmodem;..\Moudle\Updata;..\Moudle\Crc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h test.c
  group Bsp
    ../Bsp/led/: bsp_led.c
    ../Bsp/systick/: bsp_SysTick.c
    ../Bsp/sdram/: bsp_sdram.c
    ../Bsp/uart/: bsp_debug_usart.c bsp_updata_usart.c
    ../Bsp/internal_flash/: bsp_internal_flash.c
  group Moudle/Mmodem
    ../Moudle/Mmodem/: mmodem.c
  group Moudle/Updata
    ../Moudle/Updata/: updata.c
  group Moudle/Crc
    ../Moudle/Crc/: crc.c
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dbgmcu.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_spdifrx.c stm32f4xx_spi.c
